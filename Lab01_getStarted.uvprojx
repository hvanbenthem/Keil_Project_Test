# Keil uVision project Lab01_getStarted.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab01_getStarted
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:Startup 2.5.0
